# Keil uVision project rtc.uvprojx, settings and files
target nrf52832_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtc +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10040 NRF52
  c include: ..\components\drivers_nrf\hal;..\components\drivers_nrf\common;..\bsp;..\..;..\components\libraries\util;..\config;..\components\drivers_nrf\nrf_soc_nosd;..\components\toolchain;..\components\drivers_nrf\clock;..\config;..\components\drivers_nrf\config;..\components\drivers_nrf\rtc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c
  group nRF_Drivers
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group nRF_Libraries
    ../components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c app_util_platform.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
