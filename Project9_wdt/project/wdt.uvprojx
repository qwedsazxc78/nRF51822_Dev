# Keil uVision project wdt.uvprojx, settings and files
target nrf51822_xxaa (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wdt +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BOARD_PCA10040 SWI_DISABLE0 NRF52
  c include: ..\components\drivers_nrf\delay;..\components\drivers_nrf\hal;..\components\drivers_nrf\common;..\components\drivers_nrf\uart;..\components\drivers_nrf\wdt;..\bsp;..\..;..\components\libraries\uart;..\components\libraries\util;..\components\drivers_nrf\config;..\components\drivers_nrf\nrf_soc_nosd;..\components\toolchain;..\components\libraries\button;..\config;..\components\drivers_nrf\clock;..\components\libraries\timer;..\components\drivers_nrf\gpiote
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c
  group nRF_Drivers
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
  group Board Support
    ../bsp/: bsp.c
  group nRF_Libraries
    ../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../components/libraries/button/: app_button.c
    ../components/libraries/timer/: app_timer.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
