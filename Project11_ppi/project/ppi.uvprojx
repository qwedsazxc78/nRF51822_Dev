# Keil uVision project ppi.uvprojx, settings and files
target nrf52832_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ppi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BSP_DEFINES_ONLY BOARD_PCA10040 NRF52
  c include: ..\components\drivers_nrf\delay;..\components\drivers_nrf\hal;..\components\drivers_nrf\common;..\components\drivers_nrf\uart;..\bsp;..\components\libraries\uart;..\components\libraries\util;..\components\drivers_nrf\config;..\components\drivers_nrf\nrf_soc_nosd;..\components\toolchain;..\components\libraries\fifo;..\config;..\components\drivers_nrf\timer;..\components\drivers_nrf\ppi;..\..
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c
  group nRF_Drivers
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../components/drivers_nrf/ppi/: nrf_drv_ppi.c
  group nRF_Libraries
    ../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../components/libraries/util/: app_util_platform.c app_error.c nrf_assert.c app_error_weak.c
    ../components/libraries/fifo/: app_fifo.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
